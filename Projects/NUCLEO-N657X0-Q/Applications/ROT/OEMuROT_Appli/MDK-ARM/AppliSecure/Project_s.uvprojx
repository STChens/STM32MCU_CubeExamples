# Keil uVision project Project_s.uvprojx, settings and files
target STM32N6570-DK_OEMuROT_Appli_Secure (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00040000) XRAM(0x24000000,0x3E0000) XRAM2(0x25000000,0x01000000) XRAM3(0x28000000,0x00008000) CPUTYPE("Cortex-M55") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project_s
  AfterMake: fromelf #L --bincombined --output=$L"\..\..\..\Binary\rot_tz_s_app.bin"
  AfterMake: ..\postbuild.bat "secure"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_HAL_DRIVER
  c include: ../../AppliSecure/Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal;../../Secure_nsclib
  library: MicroLIB
  memory RVCT4: ROM 0x34000400 size 0x63c00
  memory RVCT6: RAM 0x24000000 size 0x3e0000
  memory RVCT7: RAM 0x25000000 size 0x1000000
  memory RVCT8: RAM 0x28000000 size 0x8000
  memory RVCT9: RAM 0x34064000 size 0x9c000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\stm32n657xx_s.sct
  link misc: --import-cmse-lib-out=./../../Secure_nsclib/secure_nsclib.o
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../AppliSecure/Src/: system_stm32n6xx_s.c
  group Application/MDK-ARM
    ./: startup_stm32n657xx.c
  group Drivers/STM32N6xx_HAL_Drivers
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_xspi.c stm32n6xx_hal_bsec.c
  group Application/User
    ../../AppliSecure/Src/: low_level_device.c low_level_ext_flash.c main.c secure_nsc.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Middlewares/STM32_ExtMem_Manager/NOR_SFDP
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
  group Middlewares/STM32_ExtMem_Manager/PSRAM
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
  group Middlewares/STM32_ExtMem_Manager/SAL
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
