<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>C:\Users\chens\STM32Cube\Repository\N6_V1.1.0\Projects\NUCLEO-N657X0-Q\Applications\ROT\OEMuROT_Appli\MDK-ARM\Project.uvmpw</WorkspaceName>

  <project>
    <PathAndName>.\AppliSecure\Project_s.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\AppliNonSecure\Project_ns.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

</ProjectWorkspace>
