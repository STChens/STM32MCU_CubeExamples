# IAR project Project_s.ewp, settings and files
configuration Nucleo-N657X0_OEMuROT_Appli_Secure (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\..\AppliSecure\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\nor_sfdp; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\sal; ..\..\Secure_nsclib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../Binary/rot_tz_s_app.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../AppliSecure/Src/: low_level_device.c low_level_ext_flash.c main.c secure_nsc.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Drivers/CMSIS
    ./: startup_stm32n657xx.s
    ../../AppliSecure/Src/: system_stm32n6xx_s.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
  group Middlewares/STM32_ExtMem_Manager/SAL
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
  group Middlewares/STM32_ExtMem_Manager/SFDP
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
