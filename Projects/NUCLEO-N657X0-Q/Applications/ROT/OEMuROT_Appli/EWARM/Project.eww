<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AppliSecure\Project_s.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AppliNonSecure\Project_ns.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>Project_s</project>
                <configuration>Nucleo-N657X0_OEMuROT_Appli_Secure</configuration>
            </member>
            <member>
                <project>Project_ns</project>
                <configuration>Nucleo-N657X0_OEMuROT_Appli_NonSecure</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
