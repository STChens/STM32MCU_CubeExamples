# Keil uVision project Project.uvprojx, settings and files
target STM32N6570-DK_OEMuROT_Boot (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00040000) XRAM(0x24000000,0x3E0000) XRAM2(0x25000000,0x01000000) XRAM3(0x28000000,0x00008000) CPUTYPE("Cortex-M55") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Boot
  BeforeMake: $J\..\bin\armclang --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -DSTM32N657xx -DBL2 -I..\..\Linker -I..\Inc -I..\..\..\..\..\..\Drivers\CMSIS\Include -I..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include -I..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc  ..\Src\image_macros_to_preprocess_bl2.c -o image_macros_preprocessed_bl2.c
  AfterMake: fromelf.exe #L --bin --output=$L"\..\..\Binary\OEMuROT_Boot.bin"
  AfterMake: postbuild.bat
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_HAL_DRIVER,NDEBUG,MCUBOOT_TARGET_CONFIG=<flash_layout.h>,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,MCUBOOT_DOUBLE_SIGN_VERIF,BL2,DEFAULT_UART_BAUDRATE=115200,OEMUROT_DEV_MODE,BOOT_MAX_ALIGN=16,BL2_USE_SFDP_EXT_FLASH_INFO,USE_FULL_ASSERT,OEMUROT_ENABLE,BOOTROM_FORMAT,FLOW_CONTROL, BOOT_TEST_MENU
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../Middlewares/Third_Party/mbedtls/include;../../../../../../Middlewares/Third_Party/mbedtls/include/psa;../../../../../../Middlewares/Third_Party/mcuboot;../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot;../../../../../../Middlewares/Third_Party/mcuboot/bl2/include;../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/include;../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/include;../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src;../../../../../../Middlewares/Third_Party/mcuboot/ext/hal/Inc;../../../../../../Middlewares/Third_Party/mcuboot/ext/mbedtls-asn1/include;../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common;../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/driver;../../../../../../Middlewares/Third_Party/mcuboot/platform/include;../../../../../../Middlewares/ST/STM32_ExtMem_Manager;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal
  library: MicroLIB
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT6: RAM 0x24000000 size 0x3e0000
  memory RVCT7: RAM 0x25000000 size 0x1000000
  memory RVCT8: RAM 0x28000000 size 0x8000
  memory RVCT9: RAM 0x341c0000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\stm32n657xx.sct
  link misc: --predefine=-I../Inc/
  group Doc
    ../: README.md
  group Drivers/STM32N6xx_HAL_drivers
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_cryp.c stm32n6xx_hal_cryp_ex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_hash.c stm32n6xx_hal_icache.c stm32n6xx_hal_mce.c stm32n6xx_hal_pka.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_rng.c stm32n6xx_hal_rng_ex.c stm32n6xx_hal_rtc.c stm32n6xx_hal_rtc_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_xspi.c
  group Drivers/CMSIS
    ../Src/: system_stm32n6xx.c
  group Application/MDK-ARM
    ./: startup_stm32n657xx.c
  group Application/User
    ../Src/: bl2_nv_services.c boot_hal.c debug_authentication.c keys_map.c low_level_com.c low_level_ext_flash.c low_level_ext_ram.c low_level_extmem_device.c low_level_mce.c low_level_otp.c low_level_rng.c low_level_security.c sha256_alt.c stm32n6xx_hal_msp.c tick.c
  group Middlewares/mbedtls
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: aes.c asn1parse.c asn1write.c bignum.c bignum_core.c constant_time.c ecdh.c ecdsa.c ecp.c ecp_curves.c md.c memory_buffer_alloc.c platform.c platform_util.c sha256.c
  group Middlewares/mcuboot
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/: bl2_main.c flash_map_extended.c flash_map_legacy.c
    ../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ec.c image_ec256.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/src/: flash_map.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common/: uart_stdout.c
  group Middlewares/STM32_ExtMem_Manager/NOR_SFDP
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
  group Middlewares/STM32_ExtMem_Manager/PSRAM
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
  group Middlewares/STM32_ExtMem_Manager/SAL
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
