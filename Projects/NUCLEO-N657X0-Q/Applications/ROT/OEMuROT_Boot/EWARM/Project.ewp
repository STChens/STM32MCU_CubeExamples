# IAR project Project.ewp, settings and files
configuration Nucleo-N657X0_OEMuROT_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_HAL_DRIVER; NDEBUG; MCUBOOT_TARGET_CONFIG=<flash_layout.h>; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; MCUBOOT_DOUBLE_SIGN_VERIF; BL2; __INITIAL_SP=ARM_LIB_STACK$$Limit; __STACK_LIMIT=ARM_LIB_STACK$$Base; DEFAULT_UART_BAUDRATE=115200; OEMUROT_DEV_MODE; BOOT_MAX_ALIGN=16; BL2_USE_SFDP_EXT_FLASH_INFO; USE_FULL_ASSERT; OEMUROT_ENABLE; BOOTROM_FORMAT; FLOW_CONTROL; BOOT_TEST_MENU
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\mbedtls\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedtls\include\psa; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\ext\mcuboot; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\ext\mcuboot\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\src; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext\hal\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext\mbedtls-asn1\include\; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\common; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\include; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\nor_sfdp; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\psram; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\sal
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../Binary/OEMuROT_Boot.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: bl2.icf.i
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Src/: bl2_nv_services.c boot_hal.c debug_authentication.c keys_map.c low_level_com.c low_level_ext_flash.c low_level_ext_ram.c low_level_extmem_device.c low_level_mce.c low_level_otp.c low_level_rng.c low_level_security.c sha256_alt.c stm32n6xx_hal_msp.c tick.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ./: startup_stm32n657xx.s
    ../Src/: system_stm32n6xx.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_cryp.c stm32n6xx_hal_cryp_ex.c stm32n6xx_hal_dma.c stm32n6xx_hal_gpio.c stm32n6xx_hal_hash.c stm32n6xx_hal_icache.c stm32n6xx_hal_mce.c stm32n6xx_hal_pka.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_rng.c stm32n6xx_hal_rng_ex.c stm32n6xx_hal_rtc.c stm32n6xx_hal_rtc_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_xspi.c
  group Middlewares/mbedtls
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: aes.c asn1parse.c bignum.c bignum_core.c constant_time.c ecdh.c ecdsa.c ecp.c ecp_curves.c md.c memory_buffer_alloc.c platform.c platform_util.c sha256.c
  group Middlewares/mcuboot
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/: bl2_main.c flash_map_extended.c flash_map_legacy.c
    ../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ec.c image_ec256.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/src/: flash_map.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common/: uart_stdout.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
  group Middlewares/STM32_ExtMem_Manager/PSRAM
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
  group Middlewares/STM32_ExtMem_Manager/SAL
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
  group Middlewares/STM32_ExtMem_Manager/SFDP
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
